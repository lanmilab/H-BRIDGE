# Repository lanmilab/H-BRIDGE

File README.md:

# H-BRIDGE
High Power High Speed MOSFET H-Bridge

2 X Half-Bridge or Full H-Bridge.
Digital TTL/CMOS or PWM inputs.
Features Add-On headers Compatible to Arduino Nano.

Typical Applications:
  - Power Stage in Class-D Power Amplifiers
  
  - DC Motor Drivers
  - DC/DC Switching power converters
  - LED Drivers

## KiCad design hardware/h-bridge-ard/LanmiLab_H_BRIDGE.kicad_pcb

Parts:
C1, C2: 220nF; C_Rect_L7.2mm_W2.5mm_P5.00mm_FKS2_FKP2_MKS2_MKP2; Part Number R82DC3220Z360J
C3, C4, C5, C6, C7, C8, C14: 100nF/50V; C_Disc_D3.4mm_W2.1mm_P2.50mm; Part Number K104K15X7RF53L2
C9, C10: 4.7uF; C_Disc_D5.1mm_W3.2mm_P5.00mm; Part Number RDEC72A475MWK1H03B
C11, C12: 1000uF/63V; CP_Radial_D16.0mm_P7.50mm; Part Number EEUFC1J102U
C13: 100uF/63V; CP_Radial_D8.0mm_P3.50mm; Part Number ECA-1JM101
C15, C16, C17, C18: 1.8nF; C_Rect_L4.0mm_W2.5mm_P2.50mm; Part Number C320C182J1G5TA
D1, D2, D3, D4: MBR360; D_DO-201AD_P15.24mm_Horizontal; Part Number MBR360G
D5, D6, D7, D8: D_Schottky_Small; D_T-1_P5.08mm_Horizontal; Part Number SD103B-F
H1, H2, H3, H4: MountingHole_Pad; MountingHole_2.1mm
HS1, HS2, HS3, HS4: Heatsink_Pad; Heatsink_AAVID_6021BG_25.4x12.7mm__Solderable; Part Number 6021BG
J1: Screw_Terminal_01x04; TerminalBlock_4Ucon_1x04_P3.50mm_Horizontal; Part Number 31059104
J2: Screw_Terminal_01x04; TerminalBlock_Phoenix_MKDS-1,5-4-5.08_1x04_P5.08mm_Horizont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; Part Number MKDS 1,5/ 4
J3: Barrel_Jack_Switch; BarrelJack_Horizontal; Part Number 694106301002
J4: Screw_Terminal_01x02; TerminalBlock_RND_205-00012_1x02_P5.00mm_Horizontal; Part Number 31320102
JMPR1: Conn_02x02_Odd_Even; PinHeader_2x02_P2.54mm_Vertical; Part Number 10-89-7041
JMPR2: Conn_02x03_Odd_Even; PinHeader_2x03_P2.54mm_Vertical; Part Number 10-89-7061
JP1, JP2: SolderJumper_3_Bridged12; SolderJumper-3_P1.3mm_Bridged12_RoundedPad1.0x1.5mm_NumberL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
JP3: Jumper_NO_Small; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
JPC1, JPC2, JPC3: JumperCap; ShortingJumperCap-2_P2.54mm; Part Number 2-382811-0
L1, L2: 4.7uH; L_Radial_D12.0mm_P5.00mm_Neosid_SD12k_style2; Part Number 744750530047
M1: Arduino_Nano_v3.x_plug; Arduino_Nano_33_IoT_3D_NoPads
P1, P2: Conn_01x15; PinSocket_1x15_P2.54mm_Vertical; Part Number PPPC151LFBN-RC
Q1, Q2, Q3, Q4: NMOSFET; TO-220-3_Vertical; Part Number STP25N10F7
R1, R2, R3, R4: 4R7; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal; Part Number CFR16J4R7
R5, R6, R9, R10, R11, R12: 47K; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal; Part Number LR0204F47K
R7, R8: 4K7; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal; Part Number CFR16J4K7
RN1: 3K3; R_Array_SIP5; Part Number 4605X-101-332LF
U1, U2: HIP2101_SOIC; SOIC-8_3.9x4.9mm_P1.27mm; Part Number HIP2101IBZT
U3: 6 x Hex Inverter; DIP-14_W7.62mm; Part Number SN74S04N
U4: DC/DC 9V/500mA; TO-220-3_SRH05S09; Part Number SRH05S09
U5: DC/DC 5V/100mA; TO-92_Inline; Part Number LM78L05ACZ/NOPB

Connections:
/D9: JP1.3 (B), P2.12
/D10: JP2.3 (B), P2.13
/PWM1: J1.2, JMPR1.1, JP1.2 (C), R5.2, U3.3
/PWM2: J1.3, JMPR2.1, JP2.2 (C), R6.2, U3.13
/VO1: C1.1, J2.3, L1.2, R9.2
/VO2: C2.1, J2.2, L2.2, R10.2
/VOF1: C15.1, P1.11, R9.1, RN1.5 (R4)
/VOF2: C16.1, P1.6, R10.1, RN1.4 (R3)
/VOS1: C6.2, D1.2 (A), D2.1 (K), L1.1, Q1.3 (S), Q2.2 (D), R11.2, U1.4 (HS)
/VOS2: C8.2, D3.2 (A), D4.1 (K), L2.1, Q3.3 (S), Q4.2 (D), R12.2, U2.4 (HS)
/VOSF1: C17.1, P1.5, R11.1, RN1.3 (R2)
/VOSF2: C18.1, P1.7, R12.1, RN1.2 (R1)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C7.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, D2.2 (A), D4.2 (A), HS1.1, HS2.1, HS3.1, HS4.1, J1.1, J2.1, J2.4, J3.2, J3.3, J4.2, P1.14, P2.4, Q2.3 (S), Q4.3 (S), R5.1, R6.1, R8.1, RN1.1 (common), U1.7 (VSS), U2.7 (VSS), U3.5, U3.7 (GND), U3.9, U4.2 (GND), U5.2 (GND)
unnamed: C6.1, U1.2 (HB)
unnamed: C8.1, U2.2 (HB)
unnamed: D5.1 (K), R1.1, U1.3 (HO)
unnamed: D5.2 (A), Q1.1 (G), R1.2
unnamed: D6.1 (K), R2.1, U1.8 (LO)
unnamed: D6.2 (A), Q2.1 (G), R2.2
unnamed: D7.1 (K), R3.1, U2.3 (HO)
unnamed: D7.2 (A), Q3.1 (G), R3.2
unnamed: D8.1 (K), R4.1, U2.8 (LO)
unnamed: D8.2 (A), Q4.1 (G), R4.2
unnamed: J1.4, R7.1, R8.2
unnamed: JMPR1.2, JMPR1.4, U1.5 (HI)
unnamed: JMPR1.3, U3.2
unnamed: JMPR2.2, JMPR2.4, U2.5 (HI)
unnamed: JMPR2.3, U3.10
unnamed: JMPR2.5, U2.6 (LI)
unnamed: JMPR2.6, U3.11, U3.12
unnamed: JP1.1 (A), P2.8
unnamed: JP2.1 (A), P2.9
unnamed: JP3.1, P1.2
unnamed: U1.6 (LI), U3.1, U3.4
VCC: C14.1, JP3.2, P1.12, R7.2, U3.14 (VCC), U5.1 (VO)
VD: C3.1, C4.1, C9.1, C10.1, C11.1, C12.1, D1.1 (K), D3.1 (K), J3.1, J4.1, Q1.2 (D), Q3.2 (D), U4.1 (VI)
VDD: C5.1, C7.1, C13.1, P1.15, U1.1 (VDD), U2.1 (VDD), U4.3 (VO), U5.3 (VI)

Notes on the sheet:
MOSFET H-Bridge
LanmiLab H-BRIDGE High Power High Speed MOSFET H-Bridge Arduino Add-On Compatible github.com/lanmilab/H-BRIDGE twitter.com/lanmiLab
1.01

Board: 2 copper layers, 100.0 x 50.0 mm, 73 parts (0 on the bottom side), 37 nets.

File hardware/h-bridge-ard/Production/Assembly/MicroHelios_H-Bridge_BOM.csv:

Reference, Quantity, Value, Footprint, Datasheet, Part Number, Alternative, Note
C10 C9 ,2,"4.7uF","Capacitor_THT:C_Disc_D5.1mm_W3.2mm_P5.00mm","http://www.farnell.com/datasheets/2728346.pdf?_ga=2.25777050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","RDEC72A475MWK1H03B","",""
C12 C11 ,2,"1000uF/63V","Capacitor_THT:CP_Radial_D16.0mm_P7.50mm","https://www.mouser.com/datasheet/2/315/ABA0000C1218-1131230.pdf","EEUFC1J102U","",""
C13 ,1,"100uF/63V","Capacitor_THT:CP_Radial_D8.0mm_P3.50mm","https://www.mouser.com/datasheet/2/315/ABA0000C1218-1131230.pdf","ECA-1JM101","",""
C14 C4 C8 C7 C3 C6 C5 ,7,"100nF/50V","Capacitor_THT:C_Disc_D3.4mm_W2.1mm_P2.50mm","http://www.farnell.com/datasheets/2045792.pdf?_ga=2.26162919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","K104K15X7RF53L2","",""
C15 C16 C17 C18 ,4,"1.8nF","Capacitor_THT:C_Rect_L4.0mm_W2.5mm_P2.50mm","http://www.farnell.com/datasheets/2739049.pdf?_ga=2.63973551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","C320C182J1G5TA","",""
C2 C1 ,2,"220nF","Capacitor_THT:C_Rect_L7.2mm_W2.5mm_P5.00mm_FKS2_FKP2_MKS2_MKP2","http://www.farnell.com/datasheets/2752854.pdf?_ga=2.26667709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","R82DC3220Z360J","",""
D4 D3 D2 D1 ,4,"MBR360","Diode_THT:D_DO-201AD_P15.24mm_Horizontal","http://www.onsemi.com/pub_link/Collateral/MBR340-D.PDF","MBR360G","",""
D8 D7 D6 D5 ,4,"D_Schottky_Small","Diode_THT:D_T-1_P5.08mm_Horizontal","https://www.diodes.com/assets/Datasheets/ds11009.pdf","SD103B-F","",""
H1 H2 H3 H4 ,4,"MountingHole_Pad","MountingHole:MountingHole_2.1mm","~","","","M2.5 Bolt"
HS1 HS2 HS3 HS4 ,4,"Heatsink_Pad","_Heatsink:Heatsink_AAVID_6021BG_25.4x12.7mm__Solderable","https://www.boydcorp.com/aavid-datasheets/Board-Level-Coolin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","6021BG","590102B03600G",""
J1 ,1,"Screw_Terminal_01x04","TerminalBlock_4Ucon:TerminalBlock_4Ucon_1x04_P3.50mm_Horizontal","http://www.farnell.com/datasheets/1838842.pdf?_ga=2.60638509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","31059104","",""
J2 ,1,"Screw_Terminal_01x04","TerminalBlock_Phoenix:TerminalBlock_Phoenix_MKDS-1,5-4-5.08_1x04_P5.08mm_Horizontal","http://www.farnell.com/datasheets/2363060.pdf?_ga=2.26159549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","MKDS 1,5/ 4","",""
J3 ,1,"Barrel_Jack_Switch","Barrel_Jack:BarrelJack_Horizontal","https://www.we-online.de/katalog/datasheet/6941xx301002.pdf","694106301002","",""
J4 ,1,"Screw_Terminal_01x02","TerminalBlock_RND:TerminalBlock_RND_205-00012_1x02_P5.00mm_Horizontal","http://www.farnell.com/datasheets/2336346.pdf?_ga=2.63964335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","31320102","",""
JMPR1 ,1,"Conn_02x02_Odd_Even","Connector_PinHeader_2.54mm:PinHeader_2x02_P2.54mm_Vertical","~","10-89-7041","",""
JMPR2 ,1,"Conn_02x03_Odd_Even","Connector_PinHeader_2.54mm:PinHeader_2x03_P2.54mm_Vertical","~","10-89-7061","",""
JP2 JP1 ,2,"SolderJumper_3_Bridged12","Jumper:SolderJumper-3_P1.3mm_Bridged12_RoundedPad1.0x1.5mm_NumberLabels","~","","","Not Populated, Configuration Jumper"
JP3 ,1,"Jumper_NO_Small","Jumper:SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm","~","","","Not Populated, Configuration Jumper"
JPC2 JPC3 JPC1 ,3,"JumperCap","_Jumper:ShortingJumperCap-2_P2.54mm","http://www.farnell.com/datasheets/39272.pdf?_ga=2.94235675.7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","2-382811-0","",""
L2 L1 ,2,"4.7uH","Inductor_THT:L_Radial_D12.0mm_P5.00mm_Neosid_SD12k_style2","http://www.farnell.com/datasheets/1951882.pdf?_ga=2.928049.1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","744750530047","",""
M1 ,1,"Arduino_Nano_v3.x_plug","Module:Arduino_Nano_33_IoT_3D_NoPads","https://www.arduino.cc/en/uploads/Main/ArduinoNanoManual23.pdf","","","Add-on Board"
P2 P1 ,2,"Conn_01x15","Connector_PinSocket_2.54mm:PinSocket_1x15_P2.54mm_Vertical","https://media.digikey.com/pdf/Data%20Sheets/Sullins%20PDFs/F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","PPPC151LFBN-RC","",""
Q4 Q3 Q2 Q1 ,4,"NMOSFET","Package_TO_SOT_THT:TO-220-3_Vertical","https://www.st.com/resource/en/datasheet/stp25n10f7.pdf","STP25N10F7","",""
R4 R3 R2 R1 ,4,"4R7","Resistor_THT:R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal","http://www.farnell.com/datasheets/1723854.pdf?_ga=2.26253927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","CFR16J4R7","",""
R5 R6 R9 R10 R11 R12 ,6,"47K","Resistor_THT:R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal","http://www.farnell.com/datasheets/1723854.pdf?_ga=2.26253927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","CFR16J4R7","",""
R7 R8 ,2,"4K7","Resistor_THT:R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal","http://www.farnell.com/datasheets/1723854.pdf?_ga=2.26253927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","CFR16J4K7","",""
RN1 ,1,"3K3","Resistor_THT:R_Array_SIP5","http://www.farnell.com/datasheets/682196.pdf?_ga=2.258286602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","4605X-101-332LF","",""
U2 U1 ,2,"HIP2101_SOIC","Package_SO:SOIC-8_3.9x4.9mm_P1.27mm","http://www.intersil.com/content/dam/Intersil/documents/hip2/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","HIP2101IBZT","UCC27211D",""
U3 ,1,"6 x Hex Inverter","Package_DIP:DIP-14_W7.62mm","http://www.ti.com/lit/ds/symlink/sn74s04.pdf","SN74S04N","",""
U4 ,1,"DC/DC 9V/500mA","TO:TO-220-3_SRH05S09","https://www.xppower.com/portals/0/pdfs/SF_SRH05.pdf","SRH05S09","",""
U5 ,1,"DC/DC 5V/100mA","Package_TO_SOT_THT:TO-92_Inline","http://www.fairchildsemi.com/ds/LM/LM78L05A.pdf","LM78L05ACZ/NOPB","",""

## Commit log

2020-02-12 Finished PCB Design
2020-02-12 PCB Fabrication gerbers added
2020-02-12 Finished V1.0 Design Files
2020-02-12 Create Licence
2020-07-05 Silkscreen update
2020-07-05 V1.01 release
2020-07-05 Link update
2020-07-05 Update Licence
2020-07-05 Inductor part number change
2020-07-07 Application link for Class D Amplifier
